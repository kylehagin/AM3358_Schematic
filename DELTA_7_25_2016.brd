# Repository kylehagin/AM3358_Schematic (continued)

## EAGLE design DELTA_7_25_2016.brd (continued)

Schematic: DELTA_7_25_2016.sch, sheet 9

Parts:
C147, C148, C150, C151, C156, C158, C161, C162, C164, C613: 0.1uf,16V; C402
C149, C154, C157: 0.01uf,16V; C402
C152: 4.7uF,6.3V; C402
C153, C155: 27pF,50V; C402
FB6, FB7, FB8: 150OHM800mA; L0603
P7: JTAG; MOLEX_79109-1004
R162, R176, R179, R186: 4.75K,1%; R0402
R163, R164, R165, R166, R168, R169, R170, R171, R172: 0,1%; R0402
R167: 12.1K,1%; R0402
R173, R174, R187: 10K,1%; R0402
R175, R188: 2.2K,1%; R0402
R177, R178, R180, R183, R184, R185: 0,DNI; R0402
R181: 10K,1%,DNI; R0402
R182: 100,1%,DNI; R0402
U3: (EEPROM)93C46BT-I/OT; SOT-23-6
U12: FT2232HQ; QFN64-HQ
U14: SN74LVC2G00DCU; DCU(S-PDSO-G8)
U16: SN74LVC2G07DCK; DCK(R-PDSO-G6)
Y6: 12MHz 50ppm; 5X8

Connections:
CD/EMU4: R185.1; also elsewhere on the board
CLKOUT2: R184.2; also elsewhere on the board
DGND: C147.2, C148.2, C149.2, C150.2, C151.2, C152.2, C153.2, C154.1, C155.2, C156.1, C157.2, C158.2, C161.2, C162.2, C164.2, C613.2, P7.8, P7.10, P7.12, P7.16, P7.20, R167.1, R177.2, R186.1, U3.2 (GND), U12.1 (GND0), U12.5 (GND1), U12.10 (AGND), U12.11 (GND2), U12.13 (TEST), U12.15 (GND3), U12.25 (GND4), U12.32 (ACBUS5/GPIOH5), U12.35 (GND5), U12.47 (GND6), U12.51 (GND7), U14.4 (GND), U16.2 (GND); also elsewhere on the board
EMU2R: P7.17, R183.2
EMU3R: P7.18, R184.1
EMU4R: P7.19, R185.2
EMU_RSTN: C156.2, P7.15, R182.2
FT_DM: U12.7 (DM); also elsewhere on the board
FT_DP: U12.8 (DP); also elsewhere on the board
FT_SRESET: R162.1, U12.26 (ACBUS0/TXDEN/GPIOH0), U14.1 (I0)
FT_SRESETB: R163.2, U16.6 (O)
FT_SRESETN: R172.2, U14.3 (O)
FT_VBUS: R181.1, U12.59 (BCBUS7/GPIOH7), U14.2 (I1); also elsewhere on the board
F_ADBUS0: R164.1, U12.16 (ADBUS0/TXD/TCK/SK)
F_ADBUS1: R165.1, U12.17 (ADBUS1/RXD/TDI/DO)
F_ADBUS2: R166.1, U12.18 (ADBUS2/RTS#/TDO/DI)
F_ADBUS3: R168.1, U12.19 (ADBUS3/CTS#/TMS/CS)
F_ADBUS4: R169.1, U12.21 (ADBUS4/DTR#/GPIOL0)
F_ADBUS6: R170.1, U12.23 (ADBUS6/DCD#/GPIOL2)
F_ADBUS7: R171.1, U12.30 (ACBUS4/TXLED#/GPIOH4)
F_EECS: R173.2, U3.5 (CS), U12.63 (EECS)
F_EEDATA: R188.2, U3.3 (DI), U12.61 (EEDATA)
F_EEDOUT: R187.2, R188.1, U3.1 (DO)
F_EESK: R174.2, U3.4 (CLK), U12.62 (EECLK)
JTAG_EMU0: P7.13, R170.2, R176.1; also elsewhere on the board
JTAG_EMU1: P7.14, R171.2, R179.1; also elsewhere on the board
JTAG_TCK: R164.2, R178.1, R180.1; also elsewhere on the board
JTAG_TDI: P7.3, R165.2; also elsewhere on the board
JTAG_TDO: P7.7, R166.2; also elsewhere on the board
JTAG_TMS: P7.1, R168.2; also elsewhere on the board
JTAG_TRSTN: P7.2, R169.2, R186.2; also elsewhere on the board
unnamed: R167.2, U12.6 (REF)
unnamed: FB8.2, U12.50 (VREGIN)
unnamed: C158.1, FB7.2, U12.4 (VPHY)
unnamed: C161.1, FB6.2, U12.9 (VPLL)
unnamed: R175.2, U12.14 (RESET#)
unnamed: P7.11, R180.2
unnamed: P7.9, R178.2
unnamed: R172.1, R182.1, U16.1 (I)
SYS_WARMRESETN: R163.1; also elsewhere on the board
TDIS: P7.4, R177.1
UART0_CTS: U12.40 (BDBUS2/RTS#/TDO/DI); also elsewhere on the board
UART0_RTS: U12.41 (BDBUS3/CTS#/TMS/CS); also elsewhere on the board
UART0_RX: U12.39 (BDBUS1/RXD/TDI/DO); also elsewhere on the board
UART0_TX: U12.38 (BDBUS0/TXD/TCK/SK); also elsewhere on the board
VCC: R179.2; also elsewhere on the board
VDD_1V8FT: C152.1, C162.1, C164.1, C613.1, U12.12 (VCORE0), U12.37 (VCORE1), U12.49 (VREGOUT), U12.64 (VCORE2)
VDD_3V3B: C147.1, C148.1, C149.1, C150.1, C151.1, C154.2, C157.1, FB6.1, FB7.1, FB8.1, P7.5, R162.2, R173.1, R174.1, R175.1, R176.2, R181.2, R187.1, U3.6 (VCC), U12.20 (VCCIO0), U12.28 (ACBUS2/GPIOH2), U12.31 (VCCIO1), U12.42 (VCCIO2), U12.56 (VCCIO3), U14.8 (VCC), U16.5 (VCC); also elsewhere on the board
XDMA_EVENT_INTR0: R183.1; also elsewhere on the board
XTIN: C153.1, U12.2 (OSCI), Y6.1 (X1)
XTOUT: C155.1, U12.3 (OSC0), Y6.2 (X2)

Schematic: DELTA_7_25_2016.sch, sheet 10

Parts:
C6: 4.7uF,6.3V; C0402
C159: 10uF,10V; C0402
C160, C166: 0.1uf,16V; C0402
IC2: TPS77301; SOP-08
P4: MICROSD_SD_MODE; MICRO_SD_CONNECTOR
P8, P9: FEMALE HEADER 2x23; FE25-2
R150: 52.3K,1%; R0402
R189: 30.1K,1%; R0402
R190, R191, R192, R193, R194, R195, R196: 10K,1%; R0402
R197: 0,1%; R0402

Connections:
3V3EXP_FB: C166.2, IC2.1 (FB/SENSE), R150.1, R189.2
AIN0: P9.39; also elsewhere on the board
AIN1: P9.40; also elsewhere on the board
AIN2: P9.37; also elsewhere on the board
AIN3: P9.38; also elsewhere on the board
AIN4: P9.33; also elsewhere on the board
AIN5: P9.36; also elsewhere on the board
AIN6: P9.35; also elsewhere on the board
CD/EMU4: R197.1; also elsewhere on the board
CLKOUT2: P9.41; also elsewhere on the board
DB0: P8.45; also elsewhere on the board
DB1: P8.46; also elsewhere on the board
DB2: P8.43; also elsewhere on the board
DB3: P8.44; also elsewhere on the board
DB4: P8.41; also elsewhere on the board
DB5: P8.42; also elsewhere on the board
DB6: P8.39; also elsewhere on the board
DB7: P8.40; also elsewhere on the board
DB8: P8.37; also elsewhere on the board
DGND: C6.2, C159.2, C160.2, IC2.4 (GND), P4.6 (VSS), P4.9 (GND), P8.1, P8.2, P9.1, P9.2, P9.43, P9.44, P9.45, P9.46, R189.1; also elsewhere on the board
DISPLAY_RST: P9.27; also elsewhere on the board
EHRPWM1A: P9.14; also elsewhere on the board
EHRPWM1B: P9.16; also elsewhere on the board
EHRPWM2A: P8.19; also elsewhere on the board
EHRPWM2B: P8.13; also elsewhere on the board
FMARK: P9.25; also elsewhere on the board
GND: P4.10 (CD), P4.12 (GND2), P4.13 (GND3), P4.14 (GND4); also elsewhere on the board
GNDA_ADC: P9.34
GPIO0_26: P8.14; also elsewhere on the board
GPIO0_27: P8.17; also elsewhere on the board
GPIO1_0: P8.25; also elsewhere on the board
GPIO1_2: P8.5; also elsewhere on the board
GPIO1_3: P8.6; also elsewhere on the board
GPIO1_4: P8.23; also elsewhere on the board
GPIO1_5: P8.22; also elsewhere on the board
GPIO1_6: P8.3; also elsewhere on the board
GPIO1_7: P8.4; also elsewhere on the board
GPIO1_12: P8.12; also elsewhere on the board
GPIO1_13: P8.11; also elsewhere on the board
GPIO1_14: P8.16; also elsewhere on the board
GPIO1_15: P8.15; also elsewhere on the board
GPIO1_16: P9.15; also elsewhere on the board
GPIO1_28: P9.12; also elsewhere on the board
GPIO1_29: P8.26; also elsewhere on the board
GPIO1_30: P8.21; also elsewhere on the board
GPIO1_31: P8.20; also elsewhere on the board
GPIO2_1: P8.18; also elsewhere on the board
GPIO2_22: P8.27; also elsewhere on the board
GPIO2_23: P8.29; also elsewhere on the board
GPIO2_24: P8.28; also elsewhere on the board
GPIO2_25: P8.30; also elsewhere on the board
I2C1_SCL: P9.17; also elsewhere on the board
I2C1_SDA: P9.18; also elsewhere on the board
I2C2_SCL: P9.19; also elsewhere on the board
I2C2_SDA: P9.20; also elsewhere on the board
IM1: P9.42; also elsewhere on the board
LED_DISPLAY: P9.23; also elsewhere on the board
MMC0_CLKO: P4.5 (CLK), R192.1; also elsewhere on the board
MMC0_CMD: P4.3 (CMD), R191.1; also elsewhere on the board
MMC0_DAT0: P4.7 (DATA0), R193.1; also elsewhere on the board
MMC0_DAT1: P4.8 (DATA1), R194.1; also elsewhere on the board
MMC0_DAT2: P4.1 (DATA2), R190.1; also elsewhere on the board
MMC0_DAT3: P4.2 (CD/DATA3), R195.1; also elsewhere on the board
PWR_BUT: P9.9; also elsewhere on the board
SD_CD: P4.11 (GND1), P4.15 (GND1), R196.2, R197.2
SPI1_D0: P9.29; also elsewhere on the board
SPI1_D1: P9.30; also elsewhere on the board
SPI1_SCLK: P9.31; also elsewhere on the board
SYS_5V: P9.7, P9.8; also elsewhere on the board
SYS_RESETN: P9.10; also elsewhere on the board
SYS_VOLT: C6.1, IC2.5 (IN1), IC2.6 (IN2); also elsewhere on the board
TIMER4: P8.7; also elsewhere on the board
TIMER5: P8.9; also elsewhere on the board
TIMER6: P8.10; also elsewhere on the board
TIMER7: P8.8; also elsewhere on the board
UART1_RXD: P9.26; also elsewhere on the board
UART1_TXD: P9.24; also elsewhere on the board
UART2_RXD: P9.22; also elsewhere on the board
UART2_TXD: P9.21; also elsewhere on the board
UART3_CTSN: P8.36; also elsewhere on the board
UART3_RTSN: P8.34; also elsewhere on the board
UART4_CTSN: P8.35; also elsewhere on the board
UART4_RTSN: P8.33; also elsewhere on the board
UART4_RXD: P9.11; also elsewhere on the board
UART4_TXD: P9.13; also elsewhere on the board
UART5_CTSN: P8.31; also elsewhere on the board
UART5_RTSN: P8.32; also elsewhere on the board
UART5_RXD: P8.38; also elsewhere on the board
VDD_3V3A: C159.1, C160.1, IC2.3 (!EN), P4.4 (VDD), R190.2, R191.2, R192.2, R193.2, R194.2, R195.2; also elsewhere on the board
VDD_3V3B: R196.1; also elsewhere on the board
VDD_3V3EXP: C166.1, IC2.7 (OUT1), IC2.8 (OUT2), P9.3, P9.4, R150.2
VDD_5V: P9.5, P9.6; also elsewhere on the board
VDD_ADC: P9.32; also elsewhere on the board

Schematic: DELTA_7_25_2016.sch, sheet 11

Parts:
C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46: 4.7pF,10V; C0402
C47, C48, C49, C50, C51, C52, C53, C54: 2.2uF, 6.3V; C0402
D6, D7: IP4283CZ10; DFN2510A-10(SOT1176-1)
D8: RB751V40; SOD323(F)
FB1: 150OHM800mA; L0603
P1: 10118242-001RLF; 10118242
R18, R24: 10K,1%; R0402
R20, R21: 1.5K,5%; R0402
R22, R23: 27K,1%; R0402
RT1: RXEF010; P660A
U5: TDA19988; SOT804-4

Connections:
12MHZ: U5.27 (OSC_IN)
DGND: C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, D6.3 (G), D6.8 (G), D7.3 (G), D7.8 (G), P1.4 (DAT2_S), P1.7 (DAT1_S), P1.10 (DAT0_S), P1.13 (CLK_S), P1.16 (DDC/CEC_GND), R23.1, R24.2, U5.8 (VPB1), U5.9 (VPB0), U5.16 (VPC2), U5.17 (VPC1), U5.18 (VPC0), U5.19 (VPP), U5.53 (A0_I2C), U5.54 (A1_I2C), U5.61 (VPA2), U5.62 (VPA1), U5.63 (VPA0), U5.CP (PAD); also elsewhere on the board
DVI_+5V: P1.19 (+5V), R20.1, R21.1, RT1.2
GND: P1.S1A (MTG1), P1.S1B (MTG1), P1.S2A (MTG2), P1.S2B (MTG2), P1.S3A (MTG3), P1.S3B (MTG3), P1.S4A (MTG4), P1.S4B (MTG4); also elsewhere on the board
HDMI_1V8: C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, FB1.1, U5.5 (VDDDC0(1.8V)), U5.14 (VDDIOA(1.8V)), U5.29 (VDDDC1(1.8V)), U5.35 (VDDA0(1.8V)), U5.36 (VDDA1(TX)(1.8V)), U5.41 (VDDA2(TX)(1.8V)), U5.46 (VDDA3(TX)(1.8V)), U5.47 (VDDA(PLL0)(1.8V)), U5.48 (VDDA(PLL1)(1.8V)), U5.55 (VDDIOB(1.8V))
HDMI_CEC: D8.1 (K), P1.15 (CEC), U5.30 (CEC)
HDMI_DSCL: P1.17 (SCL), R20.2, U5.33 (DSCL)
HDMI_DSDA: P1.18 (SDA), R21.2, U5.32 (DSDA)
HDMI_HPD: P1.1 (HPLG), U5.31 (HPD)
HDMI_INT: R18.1, U5.50 (INT)
HDMI_SWING: R24.1, U5.34 (EXT_SWING)
HDMI_TX0+: D6.2, P1.9 (DAT0+), U5.40 (TX0+)
HDMI_TX0-: D6.1, P1.11 (DAT0-), U5.39 (TX0-)
HDMI_TX1+: D7.5, P1.6 (DAT1+), U5.43 (TX1+)
HDMI_TX1-: D7.4, P1.8 (DAT1-), U5.42 (TX1-)
HDMI_TX2+: D7.2, P1.3 (DAT2+), U5.45 (TX2+)
HDMI_TX2-: D7.1, P1.5 (DAT2-), U5.44 (TX2-)
HDMI_TXC-: D6.5, P1.14 (CLK-), U5.37 (TXC-)
HDM_TXC+: D6.4, P1.12 (CLK+), U5.38 (TXC+)
I2C0_SCL: U5.52 (CSCL); also elsewhere on the board
I2C0_SDA: U5.51 (CSDA); also elsewhere on the board
LCD-DATA6: C40.1, U5.6 (VPB3)
LCD_DATA0: C35.1, U5.15 (VPC3)
LCD_DATA1: C34.1, U5.13 (VPC4)
LCD_DATA2: C33.1, U5.12 (VPC5)
LCD_DATA3: C32.1, U5.11 (VPC6)
LCD_DATA4: C31.1, U5.10 (VPC7)
LCD_DATA5: C41.1, U5.7 (VPB2)
LCD_DATA7: C39.1, U5.3 (VPB4)
LCD_DATA8: C38.1, U5.2 (VPB5)
LCD_DATA9: C37.1, U5.1 (VPB6)
LCD_DATA10: C36.1, U5.64 (VPB7)
LCD_DATA11: C46.1, U5.60 (VPA3)
LCD_DATA12: C45.1, U5.59 (VPA4)
LCD_DATA13: C44.1, U5.58 (VPA5)
LCD_DATA14: C43.1, U5.57 (VPA6)
LCD_DATA15: C42.1, U5.56 (VPA7)
LCD_DE: U5.20 (DE/VREF)
LCD_HSYNC: U5.22 (HSYNC/VREF)
LCD_PCLK: U5.4 (PCLK)
LCD_VSYNC: U5.21 (VSYNC/VREF)
unnamed: R23.2, U5.49 (TEST)
unnamed: D8.2 (A), R22.1
SPI1_CS0: U5.25 (AP1); also elsewhere on the board
SPI1_D0: U5.24 (AP0); also elsewhere on the board
SPI1_SCLK: U5.23 (ACLK); also elsewhere on the board
SYS_5V: RT1.1; also elsewhere on the board
VDD_1V8: FB1.2; also elsewhere on the board
VDD_3V3B: R18.2, R22.2; also elsewhere on the board

Schematic: DELTA_7_25_2016.sch, sheet 12

Parts:
C55: 0.001uF, 50V; C0402
C56, C57, C58, C59, C60, C61, C62, C63, C64, C65, C66, C67, C69, C70, C71: 0.1uF, 6.3V; C0402
C68: 10uF,10V; C0402
C72: 10uF, 10V; C0402
R25: 240; R0402
R26, R27, R29: 10K, 1%; R0402
R30: 1.5K, 5%; R0402
U8: AS4C256M16D3L; 96FBGA

Connections:
DDR_A0: U8.N3 (A0); also elsewhere on the board
DDR_A1: U8.P7 (A1); also elsewhere on the board
DDR_A2: U8.P3 (A2); also elsewhere on the board
DDR_A3: U8.N2 (A3); also elsewhere on the board
DDR_A4: U8.P8 (A4); also elsewhere on the board
DDR_A5: U8.P2 (A5); also elsewhere on the board
DDR_A6: U8.R8 (A6); also elsewhere on the board
DDR_A7: U8.R2 (A7); also elsewhere on the board
DDR_A8: U8.T8 (A8); also elsewhere on the board
DDR_A9: U8.R3 (A9); also elsewhere on the board
DDR_A10: U8.L7 (A10); also elsewhere on the board
DDR_A11: U8.R7 (A11); also elsewhere on the board
DDR_A12: U8.N7 (A12); also elsewhere on the board
DDR_A13: U8.T3 (A13); also elsewhere on the board
DDR_A14: U8.T7 (A14)
DDR_A15: U8.M7 (A15)
DDR_BA0: U8.M2 (BA0); also elsewhere on the board
DDR_BA1: U8.N8 (BA1); also elsewhere on the board
DDR_BA2: U8.M3 (BA2); also elsewhere on the board
DDR_CASN: U8.K3 (CASN); also elsewhere on the board
DDR_CKE: R29.2, U8.K9 (CKE); also elsewhere on the board
DDR_CLK: U8.J7 (CK); also elsewhere on the board
DDR_CLKN: U8.K7 (CKN); also elsewhere on the board
DDR_CSN: U8.L2 (CSN); also elsewhere on the board
DDR_D0: U8.E3 (DQ0); also elsewhere on the board
DDR_D1: U8.F7 (DQ1); also elsewhere on the board
DDR_D2: U8.F2 (DQ2); also elsewhere on the board
DDR_D3: U8.F8 (DQ3); also elsewhere on the board
DDR_D4: U8.H3 (DQ4); also elsewhere on the board
DDR_D5: U8.H8 (DQ5); also elsewhere on the board
DDR_D6: U8.G2 (DQ6); also elsewhere on the board
DDR_D7: U8.H7 (DQ7); also elsewhere on the board
DDR_D8: U8.D7 (DQ8); also elsewhere on the board
DDR_D9: U8.C3 (DQ9); also elsewhere on the board
DDR_D10: U8.C8 (DQ10); also elsewhere on the board
DDR_D11: U8.C2 (DQ11); also elsewhere on the board
DDR_D12: U8.A7 (DQ12); also elsewhere on the board
DDR_D13: U8.A2 (DQ13); also elsewhere on the board
DDR_D14: U8.B8 (DQ14); also elsewhere on the board
DDR_D15: U8.A3 (DQ15); also elsewhere on the board
DDR_DQM0: U8.E7 (LDM); also elsewhere on the board
DDR_DQM1: U8.D3 (UDM); also elsewhere on the board
DDR_DQS0: U8.F3 (LDQS); also elsewhere on the board
DDR_DQS1: U8.C7 (UDQS); also elsewhere on the board
DDR_DQSN0: U8.G3 (LDQSN); also elsewhere on the board
DDR_DQSN1: U8.B7 (UDQSN); also elsewhere on the board
DDR_ODT: U8.K1 (ODT); also elsewhere on the board
DDR_RASN: U8.J3 (RASN); also elsewhere on the board
DDR_RESETN: R30.2, U8.T2 (RESET#); also elsewhere on the board
DDR_VREF: C55.1, C56.1, R26.2, R27.2, U8.H1 (VREF_DQ), U8.M8 (VREF_CA); also elsewhere on the board
DDR_WEN: U8.L3 (WEN); also elsewhere on the board
DGND: C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, R25.2, R27.1, R29.1, U8.A9 (VSS1), U8.B1 (VSSQ1), U8.B3 (VSS2), U8.B9 (VSSQ2), U8.D1 (VSSQ3), U8.D8 (VSSQ4), U8.E1 (VSS3), U8.E2 (VSSQ5), U8.E8 (VSSQ6), U8.F9 (VSSQ7), U8.G1 (VSSQ8), U8.G8 (VSS4), U8.G9 (VSSQ9), U8.J2 (VSS5), U8.J8 (VSS6), U8.M1 (VSS7), U8.M9 (VSS8), U8.P1 (VSS9), U8.P9 (VSS10), U8.T1 (VSS11), U8.T9 (VSS12); also elsewhere on the board
VDDS_DDR: C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, C63.1, C64.1, C65.1, C66.1, C67.1, C68.1, C69.1, C70.1, C71.1, C72.1, R26.1, R30.1, U8.A1 (VDDQ1), U8.A8 (VDDQ2), U8.B2 (VDD1), U8.C1 (VDDQ3), U8.C9 (VDDQ4), U8.D2 (VDDQ5), U8.D9 (VDD9), U8.E9 (VDDQ7), U8.F1 (VDDQ8), U8.G7 (VDD2), U8.H2 (VDDQ9), U8.H9 (VDDQ10), U8.K2 (VDD4), U8.K8 (VDD5), U8.N1 (VDD6), U8.N9 (VDD7), U8.R1 (VDD8), U8.R9 (VDD3); also elsewhere on the board
ZQ: R25.1, U8.L8 (ZQ)

Schematic: DELTA_7_25_2016.sch, sheet 13

Parts:
DISPLAY1: DISPLAY_1_54_W_CTP; PV015400KLD24C
LCD1: DISPLAY_1_22_W_CTP; YQ12006-01
Q3: DME914C10R; DMC56404
R33, R34: 10K; R0402
R35: 7.5R; R0402

Connections:
DB0: DISPLAY1.12 (DB0); also elsewhere on the board
DB1: DISPLAY1.11 (DB1); also elsewhere on the board
DB2: DISPLAY1.10 (DB2); also elsewhere on the board
DB3: DISPLAY1.9 (DB3); also elsewhere on the board
DB4: DISPLAY1.8 (DB4); also elsewhere on the board
DB5: DISPLAY1.7 (DB5); also elsewhere on the board
DB6: DISPLAY1.6 (DB6); also elsewhere on the board
DB7: DISPLAY1.5 (DB7); also elsewhere on the board
DB8: DISPLAY1.4 (DB8); also elsewhere on the board
DGND: DISPLAY1.1 (GND1), DISPLAY1.3 (GND2), DISPLAY1.21 (GND3), DISPLAY1.23 (LEDK), DISPLAY1.24 (GND4), DISPLAY1.C6 (GND1), DISPLAY1.C7 (GND2), DISPLAY1.C9 (GND3), DISPLAY1.C10 (GND4), LCD1.1 (LEDK2), LCD1.2 (LEDK1), LCD1.4 (GND), LCD1.13 (GND1), LCD1.C2 (GND), LCD1.C5 (GND1), LCD1.C8 (GND2); also elsewhere on the board
DISPLAY_RST: DISPLAY1.2 (/RESET), DISPLAY1.C5 (RESET), LCD1.10 (RESET), LCD1.C6 (RST), R33.1; also elsewhere on the board
FMARK: DISPLAY1.19 (FMARK), LCD1.5 (FMARK); also elsewhere on the board
I2C1_SCL: LCD1.C3 (SCL_CTP); also elsewhere on the board
I2C1_SDA: LCD1.C4 (SDA_CTP); also elsewhere on the board
IM1: DISPLAY1.13 (IM1); also elsewhere on the board
LEDA: DISPLAY1.22 (LEDA), LCD1.3 (LEDA), R35.1
LED_DISPLAY: R34.1; also elsewhere on the board
unnamed: Q3.2 (B), R34.2
unnamed: Q3.6 (C), R35.2
SPI1_CS0: DISPLAY1.17 (/CS), LCD1.9 (CS); also elsewhere on the board
SPI1_D0: DISPLAY1.16 (RS), DISPLAY1.C3 (SDA), LCD1.6 (SDA); also elsewhere on the board
SPI1_D1: DISPLAY1.14 (/RD), LCD1.7 (DA2); also elsewhere on the board
SPI1_SCLK: DISPLAY1.15 (/WR), DISPLAY1.C2 (SCL), LCD1.8 (CLK); also elsewhere on the board
VDD_3V3B: DISPLAY1.18 (IOVCC), DISPLAY1.20 (VCI), DISPLAY1.C1 (VDD), LCD1.11 (IOVCC), LCD1.12 (VCC), LCD1.C1 (VDD), Q3.1 (E), R33.2; also elsewhere on the board

Board: 2 copper layers, 522 parts (0 on the bottom side), 445 nets, no tracks yet.

File BOM_DELTA_7_25_2016.xlsx (part):

Description | Designator | Value | Footprint | Manufacturer | Manufacturer Part Number | Quantity | Supplier 1 | Supplier Part Number 1
4.7µF 6.3V Ceramic Capacitor X5R 0402 (1005 Metric) 0.039" L x 0.020" W (1.00mm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 | C1, C2, C6, C7, C100, C121, C139, C152 | 4.7uF, 6.3V | 0402 | Murata Electronics North America | GRM155R60J475ME47D | 8 | Digi-Key | 490-5915-1-ND
25pF 50V Ceramic Capacitor C0G, NP0 0603 (1608 Metric) 0.063" L x 0.031" W (1.6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 | C11, C12 | 25pF,50V | 0603 | Samsung Electro-Mechanics America, Inc. | CL10C250JB8NNNC | 2 | Digi-Key | 1276-2244-1-ND
10µF 10V Ceramic Capacitor X5R 0402 (1005 Metric) 0.039" L x 0.020" W (1.00mm x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 | C3, C4, C5, C8, C9, C10, C14, C15, C17, C18, C19, C21, C22, C135, C159, C165, C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 | 10uF, 10V | 0402 | Samsung Electro-Mechanics America, Inc. | CL05A106MP8NUB8 | 20 | Digi-Key | 1276-6830-1-ND
18pF 50V Ceramic Capacitor C0G, NP0 0402 (1005 Metric) 0.039" L x 0.020" W (1.0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 | C13, C137, C144, C163 | 18pF, 50V | 0402 | Murata Electronics North America | GRM1555C1H180JA01D | 4 | Digi-Key | 490-5858-1-ND
22µF 6.3V Ceramic Capacitor X5R 0402 (1005 Metric) 0.039" L x 0.020" W (1.00mm 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 | C16, C116 | 22uF, 6.3V | 0402 | AVX Corporation | 04026D226MAT2A | 2 | Digi-Key | 478-9839-1-ND
2.2µF 6.3V Ceramic Capacitor X5R 0402 (1005 Metric) 0.039" L x 0.020" W (1.00mm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 | C20, C47, C48, C49, C50, C51, C52, C53, C54 | 2.2uF, 6.3V | 0402 | Murata Electronics North America | GRM155R60J225KE95D | 9 | Digi-Key | 490-12532-1-ND
4.7pF 10V Ceramic Capacitor C0G, NP0 0402 (1005 Metric) 0.039" L x 0.020" W (1.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 | C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46 | 4.7pF, 10V | 0402 | Wurth Elektronik | 885012005005 | 16 | Digi-Key | 732-7423-1-ND
10000pF 16V Ceramic Capacitor X7R 0402 (1005 Metric) 0.039" L x 0.020" W (1.00m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 | C23, C24,C25, C26, C27, C28, C29, C102, C103, C104, C105, C106, C107, C108, C10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 | 0.01uF, 16V | 0402 | Murata Electronics North America | GRM155R71C103KA01D | 82 | Digi-Key | 490-1313-1-ND
1000pF 50V Ceramic Capacitor X7R 0402 (1005 Metric) 0.039" L x 0.020" W (1.00mm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 | C30, C55 | 0.001uF, 50V | 0402 | Murata Electronics North America | GRM155R71H102KA01D | 2 | Digi-Key | 490-1303-1-ND
0.10µF 16V Ceramic Capacitor X7R 0402 (1005 Metric) 0.039" L x 0.020" W (1.00mm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 | C119, C120, C122, C123, C136, C138, C140, C141, C142, C143, C147, C148, C150, C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 | 0.1uF, 16V | 0402 | Murata Electronics North America | GRM155R71C104KA88J | 22 | Digi-Key | 490-6328-1-ND
0.10µF 6.3V Ceramic Capacitor X7R 0402 (1005 Metric) 0.039" L x 0.020" W (1.00m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 | C56, C57, C58, C59, C60, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70, C71,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 | 0.1uF, 6.3V | 0402 | Kemet | C0402C104K9RACTU | 17 | Digi-Key | 399-4872-1-ND
470pF 50V Ceramic Capacitor X7R 0402 (1005 Metric) 0.039" L x 0.020" W (1.00mm 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 | C124 | 470pF, 5%, 50V | 0402 | Murata Electronics North America | GRM155R71H471JA01D | 1 | Digi-Key | 490-6362-1-ND
1µF 10V Ceramic Capacitor X5R 0402 (1005 Metric) 0.039" L x 0.020" W (1.00mm x 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 | C125, C189, C190, C191, C231, | 1uF, 10V | 0402 | Murata Electronics North America | GRM155R61A105KE15D | 5 | Digi-Key | 490-3890-1-ND
0.022µF 10V Ceramic Capacitor X7R 0402 (1005 Metric) 0.039" L x 0.020" W (1.00m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 | C130 | 0.022uF, 10V | 0402 | Taiyo Yuden | LMK105B7223KV-F | 1 | Digi-Key | 587-2476-1-ND
30pF 50V Ceramic Capacitor C0G, NP0 0402 (1005 Metric) 0.039" L x 0.020" W (1.0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 | C131, C132 | 30pF, 50V | 0402 | Murata Electronics North America | GRM1555C1H300JA01D | 2 | Digi-Key | 490-5935-1-ND
100µF 6.3V Aluminum Capacitors Radial, Can - SMD 2000 Hrs @ 85°C | C133 | 100uF, 6.3V | Radial, SMD Series S Type V | Panasonic Electronic Components | EEE-0JA101WR | 1 | Digi-Key | PCE3853CT-ND
27pF 50V Ceramic Capacitor C0G, NP0 0402 (1005 Metric) 0.039" L x 0.020" W (1.0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 | C153, C155 | 27pF, 50V | 0805 | Samsung Electro-Mechanics America, Inc. | CL05C270JB5NNNC | 2 | Digi-Key | 1276-1153-1-ND
LED GREEN CLEAR 0805 SMD | D1 |  |  | Dialight | 5988170107F | 1 | Digi-Key | 350-2044-1-ND
Low Current LED | D2, D3, D4, D5 | InGaAlP LED | PLCC-2 package | TOPLED | LG T67K-H2K1-24-Z | 4 | Digi-Key | 475-2679-1-ND
ESD protection for ultra high-speed interfaces | D6, D7 | TVS ARRAY | DFN2510A-10 (SOT1176-1) | NXP | IP4283CZ10-TBR | 2 | Digi-Key | 568-10487-1-ND
Schottky barrier single diodes | D8 | Schottky diodes | SOD323 (SC-76) | NXP | RB751V40,115 | 1 | Digi-Key | 568-8119-1-ND
FIXED IND 1.5NH 800MA 150 MOHM | FB1, FB4, FB5, FB6, FB7, FB8, FB9 , FB10 | 150OHM 800mA | 0603 | Toko America Inc. | PTL1608-F1N5C | 8 | Digi-Key | TKS2902CT-ND
FIXED IND 2.2UH 2.6A 115 MOHM | L1, L2, L3, L4 | 2.2uH,2.6A | 1008 (2520 Metric) | Murata Electronics North America | DFE252010P-2R2M=P2 | 4 | Digi-Key | 490-10637-1-ND
HDMI Type D Receptacle | P1 |  |  | FCI | 10118242-001RLF | 1 | Digikey | 609-4617-1-ND
USB - mini A Receptacle Connector 5 Position Surface Mount | P2 | USB - mini A |  | TE Connectivity | 1734327-1 | 1 | Digikey | A123107-ND
USB - mini A Receptacle Connector 5 Position Surface Mount | P3 | USB - mini B |  | HIROSE | UX60-MB-5ST | 1 | Digikey | H2959CT-ND
Micro SD Card Socket | P4 | microSD |  | Molex | 0492250821 | 1 | Digikey | WM3295CT-ND
DC POWER JACK - RIGHT ANGLED - THT - 2.0 & 2.5Ø -WR-DC | P5 | DC POWER JACK | THT - 2.0 & 2.5Ø -WR-DC | Wurth Elektronik | 694106301002 | 1 | Digikey | 732-5930-ND
.100” [2.54 mm] Contact Centers, Female Headers | P6 | 2x5 Female Headers | .100” [2.54 mm] | Sullins | PPTC052LFBN-RC | 1 | Digikey | S6105-ND
10 Position Receptacle Connector 0.079" (2.00mm) Surface Mount Gold | P7 | 10 Position Receptacle Connector | 0.079" (2.00mm) Surface Mount | Molex | 0791091004 | 1 | Digikey | WM18700-ND
.100” [2.54 mm] Contact Centers, Female Headers | P8, P9 | 2 x23 Female Headers | .100” [2.54 mm] | Sullins | PPPC232LFBN-RC | 2 | Digikey | S7126-ND
WE-RJ45-LAN-10/100BT | P10 | ;'RJ45-LAN-10/100BT |  | Wurth Elektronik | 7499010211A | 1 | Digikey | 732-4506-5-ND
Sitara™ ARM® Cortex®-A8 32‑Bit RISC Processor | IC1 |  | NFBGA (324) | Texas Instrument | AM3358BZCZ100 | 1 | Digikey | 296-35869-5-ND
250-mA LDO REGULATORS | IC2 |  | 8-VSSOP | Texas Instrument | TPS77301DGK | 1 | Digikey | 296-8108-5-ND
Positive Overvoltage Protection Controller with Internal Low RON NMOS FET | U1 |  | DFN6 | ON Semiconductor | NCP349MNBKTBG | 1 | Digikey | NCP349MNBKTBGOSCT-ND
Single-Chip PMIC for Battery-Powered Systems | U2 | 2-A Output Current | VQFN (48) | Texas Instrument | TPS65217BRSLR | 1 | Digikey | 296-40879-1-ND
1K Microwire Compatible Serial EEPROM | U3 | 1Kbit | SOT-23-6 | Microchip | 93C46BT-I/OT | 1 | Digikey | 93C46BT-IOTCT-ND
Low power, 150 MHz pixel rate HDMI 1.4a transmitter with 3 x 8-bit video inputs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 | U5 | 150 MHz pixel rate | SOT804-4 | NXP | TDA19988BHN C1,557 | 1 | Digikey | 568-12059-ND
DDR2 SDRAM | U6 | 16 Meg x 16 x 8 banks | 90-FBGA | Micron | MT47H128M16RT-25EC | 1 | Digikey | 557-1535-ND
256 kb I2C CMOS Serial EEPROM | U7 | 256 kb | SOIC8 | ON Semiconductor | CAT24C256WI-GT3 | 1 | Digikey | CAT24C256WI-GT3OSCT-ND
4Gb DDR3L, IC SDRAM DDR3 256M X 16 | U8 | 4Gb | 96-FBGA | Alliance Memory | AS4C256M16D3L-12BCN | 1 | Digikey | 1450-1097-ND
IC 0.5A Power-Distribution Switches | U9 | 500-Ma | DGN | Texas Instrument | TPS2051BDGNR | 1 | Digikey | 296-17313-1-ND
4-Channel ESD Solution for USB-HS/USB OTG/USB Charger Interface | U10 |  | DRY(R-PUSON-N6) | Texas Instrument | TPD4S012DRYR | 1 | Digikey | 296-24244-1-ND
2-Port USB 2.0 Hi-Speed Hub Controller | U11 |  | QFN28 | SMSC | USB2412-DZK-TR | 1 | Digikey | USB2412-DZK-CT-ND
Dual High Speed USB to Multipurpose UART/FIFO IC | U12 |  | QFN64-HQ | FTDI | FT2232HQ-REEL | 1 | Digikey | 768-1025-1-ND
Small Footprint MII/RMII 10/100 Ethernet Transceiver with HP Auto-MDIX and flex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 | U13 | 10/100 Ethernet Transceiver | 32-QFN | SMSC | LAN8710A-EZC-TR | 1 | Digikey | LAN8710A-EZC-CT-ND
Dual 2-Input Positive-NAND Gate | U14 | NAND Gate | DCK(R-PDSO-G6) | Texas Instrument | SN74LVC2G00DCUR | 1 | Digikey | 296-13258-1-ND
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

Notices in the files:
parts and their libraries:
Wurth_Elektronik_Passive_rev15d: Copyright: Würth Elektronik
con-fci: Copyright (C) 2008, Bob Starr
